* EESchema Netlist Version 1.1 (Spice format) creation date: 07/05/2013 12:43:24

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

*Sheet Name:/
R17  31 0 10K
R18  30 0 10K
R20  32 0 10K
R21  29 0 10K
R22  33 0 10K
R23  28 0 10K
U11  33 79 28 121 79 120 BSL214N
U10  32 79 29 125 79 124 BSL214N
R39  94 121 12 0,3W
R34  25 122 12 0,3W
U9  31 79 30 123 79 122 BSL214N
SCH2  17 105 DIODESCH
R14  141 67 10K
C10  0 46 0,1uF
R9  46 45 100K
C11  119 0 150nF
U4  0 141 119 0 65 46 27 153 LTC2955TS8-2
R13  153 67 10K
R12  45 27 100K
SCH1  105 46 DIODESCH
U5  45 64 105 46 46 55 IRF5810
R35  123 24 5,6 0,2W
R38  43 120 5,6 0,2W
R37  125 43 5,6 0,2W
R36  124 24 5,6 0,2W
R49  26 0 1,8K
R48  23 0 1,8K
R1  130 105 ?
D11  130 10 Bleue_Charge
C30  93 0 4,7uF
D9  127 35 Orange
R32  127 93 820
D8  36 126 Orange
R31  36 93 820
R24  111 93 820
R25  5 93 820
R26  112 93 820
R27  38 93 820
R28  129 93 820
R29  4 93 820
R58  128 93 82
U6  39 138 3 103 40 0 110 34 126 35 81 104 96 67 78 106 0 MAX7317
R6  0 105 100K
C1  105 0 2,2uF
C9  64 11 2,2uF
R11  11 47 10K
P1  20 18 48 77 19 17 51 11 JTAG
U2  159 0 117 150 100 21 11 55 57 56 22 0 118 12 113 144 0 A3950_L
C12  22 56 0,1uF
R2  0 117 5K
U1  105 105 64 64 101 99 10 11 11 47 MCP73213
X1  14 0 13 0 QUARTZ_8Z
C104  55 0 100uF
C103  55 0 100uF
C35  15 0 10nF
R55  16 0 30K
R56  16 68 13K
GS1  93 15 108 GS3
P2  15 0 68 107 109 116 Gyro
K3  93 0 115 114 USART
D4  38 103 Bleue
D3  112 3 Jaune
D1  111 39 Vert
D6  4 110 Rouge
U19  142 41 37 0 Line_4
U18  41 8 1 0 Line_3
C36  93 1 10nF
C37  93 37 10nF
R63  37 143 220
R64  142 93 33
R61  1 149 220
R54  6 145 220
R60  7 155 220
C34  93 7 10nF
C33  93 6 10nF
U16  128 62 6 0 Line_1
U17  8 62 7 0 Line_2
U20  140 62 2 0 Line_5
C39  93 2 10nF
R67  140 93 82
R65  2 148 220
R47  154 0 1,8K
R46  157 0 1,8K
R45  151 0 1,8K
R44  0 152 1,8K
C14  55 11 0,47uF
C100  55 11 220uF
C42  67 0 10uF
C16  67 0 0,1uF
U7  11 93 55 LM2940
U14  67 141 144 117 13 14 77 152 26 151 23 0 108 91 155 149 143 0 67 9 109 16 107 157 154 145 148 60 66 74 49 67 71 78 153 96 147 146 30 32 150 159 158 156 116 19 50 67 51 20 131 132 33 106 48 18 29 133 134 136 31 28 0 67 STM32F405RGT6
C4  0 54 0,22uF
C8  135 55 0,1uF
C13  52 59 0,1uF
K2  53 58 0 93 134 133 R_Motor
U3  156 0 117 158 98 53 11 55 58 59 52 0 135 54 102 144 0 A3950_R
C6  55 0 0,1uF
C5  55 0 0,1uF
K1  21 57 0 93 146 147 L_Motor
C7  118 55 0,1uF
C3  0 12 0,22uF
C26  108 0 1uF
C20  0 67 4,7uF
C21  0 67 0,1uF
C25  0 67 0,1uF
C24  0 67 0,1uF
C23  0 67 0,1uF
C27  0 49 2,2uF
C29  0 50 2,2uF
R51  132 115 510
R52  131 114 510
R16  9 0 10K
R15  55 9 20K
C15  93 11 2,2uF
D12  139 0 Blanc_5V
R19  139 93 820
C101  93 11 22uF
D2  5 138 Rouge
D5  129 40 Jaune
C41  14 0 18pF
C40  13 0 18pF
C28  108 0 0,1uF
R4  67 51 10K
R10  67 18 10K
R8  67 20 10K
R7  67 48 10K
R5  67 19 10K
R30  137 93 820
D7  137 34 Vert
R50  0 136 100K
IR1  93 25 152 108 L_Front
IR6  93 94 26 108 R_Front
IR2  42 24 151 108 L_Diag
IR5  93 42 23 108 R_Diag
IR3  93 44 157 108 L_Side
IR4  44 43 154 108 R_Side
R3  97 65 5,1K
SW1  0 97 ON/OFF
SW2  0 77 PUSH
SP1  93 95 Piezzo
U12  91 84 88 87 0 76 86 85 MCMT5-F-V
R33  84 88 3,3K
R43  76 88 1K
R42  87 76 620
R41  91 87 330
R40  67 91 2K
R53  73 0 390K
C32  70 0 4,7uF
C31  90 0 4,7uF
C17  69 89 1uF
C18  72 82 1uF
C22  0 67 1uF
C19  67 0 1uF
U13  0 69 89 72 82 67 92 0 67 0 0 0 71 77 74 0 0 78 96 83 0 0 0 0 0 73 70 90 0 0 OLED_128X64
F1  64 75 FUSE
C38  77 0 0,1uF
R66  67 77 100K
R62  61 95 12
L1  67 108 10uH
U15  66 79 60 62 79 61 BSL214N
R57  66 0 10K
R59  60 0 10K
C2  0 65 0,1uF
BT1  75 11 LYPO_2S
D10  80 81 Vert
R68  80 93 820
U8  0 67 93 MCP1703

.end
